Commit message: Modified to record gofa video

File: catkin_ws/src/air_hockey/urdf/puck.urdf (robot description, URDF)
Before this commit: robot air_hockey_puck, 1 links, 0 joints
Links:
- link puck: geometry collision cylinder length=0.010 radius=0.025; visual cylinder length=0.010 radius=0.025
